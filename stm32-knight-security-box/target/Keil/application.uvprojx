# Keil uVision project application.uvprojx, settings and files
target STM32F769I-DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ST STM32F769xx USE_FREERTOS_8 USE_OS_SYSTICK USE_IOEXPANDER USE_HAL_DRIVER STM32F769I_DISCO USE_STDPERIPH_DRIVER USE_BPP=24
  c include: ../../target/include;../../platform/os;../bsp/include/platform/stm32f7xx;../bsp/include/platform/stm32f7xx/STM32F7xx_HAL_Driver;../bsp/include/platform/stm32f7xx/CMSIS;../bsp/include;../bsp/include/vendor;../bsp/source/vendor/STM32769I_DISCO;../os/FreeRTOS8.2.0/Source/include;../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7;../../touchgfx/framework/include;../../generated/fonts/include;../../generated/gui_generated/include;../../generated/images/include;../../generated/texts/include;../../generated/videos/include;../../gui/include
  asm include: .\os\FreeRTOSV8.2.0\FreeRTOS\Source\include;.\os\FreeRTOSV8.2.0\FreeRTOS\Source\portable\RVDS\ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../: main.cpp
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../bsp/source/platform/stm32f7xx/Keil/: startup_stm32f769xx.s
  group TouchGFXHAL
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL_DSI.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: OTM8009TouchController.cpp STM32F7Instrumentation.cpp
  group HAL
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_jpeg.c
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
    ../bsp/source/vendor/Components/wm8994/: wm8994.c
    ../bsp/source/vendor/STM32769I_DISCO/: stm32f769i_discovery.c stm32f769i_discovery_audio.c stm32f769i_discovery_lcd.c stm32f769i_discovery_qspi.c stm32f769i_discovery_sd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c
  group OS
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group Lib
    ../../touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/common/: customkeyboard.cpp frontendapplication.cpp mask.cpp
    ../../gui/src/info_screen/: infopresenter.cpp infoview.cpp
    ../../gui/src/log_screen/: logpresenter.cpp logview.cpp
    ../../gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/settings_screen/: settingspresenter.cpp settingsview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp compressedfontcache.cpp compressedunmappedfontcache.cpp font_robotocondensed_regular_24_4bpp_0.cpp font_robotocondensed_regular_40_4bpp_0.cpp font_robotocondensed_regular_40_4bpp_4.cpp font_robotocondensed_regular_56_4bpp_0.cpp font_robotocondensed_regular_56_4bpp_4.cpp font_veramono_24_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_robotocondensed_regular_24_4bpp.cpp kerning_robotocondensed_regular_40_4bpp.cpp kerning_robotocondensed_regular_56_4bpp.cpp kerning_veramono_24_4bpp.cpp table_robotocondensed_regular_24_4bpp.cpp table_robotocondensed_regular_40_4bpp.cpp table_robotocondensed_regular_56_4bpp.cpp table_veramono_24_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../../generated/images/src/: bitmapdatabase.cpp image_bg_800x480.cpp image_bg_info.cpp image_edtlogo_large.cpp image_info_p.cpp image_info_r.cpp image_keyboard_background_640x392.cpp image_keyboard_key_delete_highlighted_112x80.cpp image_keyboard_key_highlighted_52x80.cpp image_keyboard_key_shift_highlighted_112x80.cpp image_keyboard_mask.cpp image_keyboard_numberpad_background.cpp image_keyboard_numberpad_key_highlighted.cpp image_lock.cpp image_log_p.cpp image_log_r.cpp image_return_p.cpp image_return_r.cpp image_settings_p.cpp image_settings_r.cpp image_smart_embedded_logo.cpp image_unlocked.cpp image_wi_fi.cpp image_wi_fi_off.cpp svgdatabase.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/images/src/__designer/: image_blue_buttons_round_edge_large.cpp image_blue_buttons_round_edge_large_pressed.cpp
    ../../generated/gui_generated/src/info_screen/: infoviewbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/log_screen/: logviewbase.cpp
    ../../generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../../generated/gui_generated/src/settings_screen/: settingsviewbase.cpp
