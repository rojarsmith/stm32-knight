# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; USE_FREERTOS_8; USE_STDPERIPH_DRIVER; STM32F769xx; STM32F769I_DISCO; USE_FLOATING_POINT; USE_IOEXPANDER; USE_OS_SYSTICK; USE_BPP=24
  ICCARM.CCIncludePath2: ../../gui/include; ..\..\target\include; ..\..\platform\os; ../../generated/fonts/include; ../../generated/images/include; ../../generated/texts/include; ../../generated/gui_generated/include; ../../touchgfx/framework/include; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7; ..\bsp\framework\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\STM32769I_DISCO; ../../generated/videos/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ../../touchgfx/lib/core/cortex_m7/IAR/touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp CompressedFontCache.cpp CompressedUnmappedFontCache.cpp Font_RobotoCondensed_Regular_24_4bpp_0.cpp Font_RobotoCondensed_Regular_40_4bpp_0.cpp Font_RobotoCondensed_Regular_40_4bpp_4.cpp Font_RobotoCondensed_Regular_56_4bpp_0.cpp Font_RobotoCondensed_Regular_56_4bpp_4.cpp Font_VeraMono_24_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_RobotoCondensed_Regular_24_4bpp.cpp Kerning_RobotoCondensed_Regular_40_4bpp.cpp Kerning_RobotoCondensed_Regular_56_4bpp.cpp Kerning_VeraMono_24_4bpp.cpp Table_RobotoCondensed_Regular_24_4bpp.cpp Table_RobotoCondensed_Regular_40_4bpp.cpp Table_RobotoCondensed_Regular_56_4bpp.cpp Table_VeraMono_24_4bpp.cpp UnmappedDataFont.cpp VectorFontRendererBuffers.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/info_screen
    ../../generated/gui_generated/src/info_screen/: InfoViewBase.cpp
  group Application/generated/gui_generated/log_screen
    ../../generated/gui_generated/src/log_screen/: LogViewBase.cpp
  group Application/generated/gui_generated/main_screen
    ../../generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group Application/generated/gui_generated/settings_screen
    ../../generated/gui_generated/src/settings_screen/: SettingsViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: BitmapDatabase.cpp image_bg_800x480.cpp image_bg_info.cpp image_edtlogo_large.cpp image_info_p.cpp image_info_r.cpp image_keyboard_background_640x392.cpp image_keyboard_key_delete_highlighted_112x80.cpp image_keyboard_key_highlighted_52x80.cpp image_keyboard_key_shift_highlighted_112x80.cpp image_keyboard_mask.cpp image_keyboard_numberpad_background.cpp image_keyboard_numberpad_key_highlighted.cpp image_lock.cpp image_log_p.cpp image_log_r.cpp image_return_p.cpp image_return_r.cpp image_settings_p.cpp image_settings_r.cpp image_smart_embedded_logo.cpp image_unlocked.cpp image_wi_fi.cpp image_wi_fi_off.cpp SVGDatabase.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: image_Blue_Buttons_Round_Edge_large.cpp image_Blue_Buttons_Round_Edge_large_pressed.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../gui/src/common/: CustomKeyboard.cpp FrontendApplication.cpp Mask.cpp
  group Application/gui/info_screen
    ../../gui/src/info_screen/: InfoPresenter.cpp InfoView.cpp
  group Application/gui/log_screen
    ../../gui/src/log_screen/: LogPresenter.cpp LogView.cpp
  group Application/gui/main_screen
    ../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/settings_screen
    ../../gui/src/settings_screen/: SettingsPresenter.cpp SettingsView.cpp
  group Application/main
    ../: main.cpp
  group Board/STM32F769I-DISCO
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F769I-DISCO/BSP
    ../bsp/source/bsp/: OTM8009TouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F769I-DISCO/Vendor
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/mfxstm32l152/: mfxstm32l152.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
    ../bsp/source/vendor/STM32769I_DISCO/: stm32f769i_discovery.c stm32f769i_discovery_audio.c stm32f769i_discovery_lcd.c stm32f769i_discovery_qspi.c stm32f769i_discovery_sd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c
    ../bsp/source/vendor/Components/wm8994/: wm8994.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL_DSI.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f769xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
