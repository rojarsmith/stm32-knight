# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ../../../../target/include;../../../../platform/os;../../../../../../touchgfx/4.8.0/touchgfx/framework/include/platform/core/arm/cortex-m/CMSIS;../../../../../../touchgfx/4.8.0/touchgfx/framework/include/platform/hal/ST/mcu/stm32f7xx;../../../../../../touchgfx/4.8.0/touchgfx/framework/include/platform/hal/ST/mcu/stm32f7xx/CMSIS;../../../../../../touchgfx/4.8.0/touchgfx/framework/include/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver;../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/include;../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/include/vendor;../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery;../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/include;../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7;../../../../touchgfx/framework/include;../../../../generated/fonts/include;../../../../generated/gui_generated/include;../../../../generated/images/include;../../../../generated/texts/include;../../../../generated/videos/include;../../../../gui/include
  asm include: .\os\FreeRTOSV8.2.0\FreeRTOS\Source\include;.\os\FreeRTOSV8.2.0\FreeRTOS\Source\portable\RVDS\ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../../../: main.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/Keil/: startup_stm32f746xx.s
  group Gui
    ../../../../gui/src/common/: FrontendApplication.cpp
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/pooltemp_screen/: PoolTempPresenter.cpp PoolTempView.cpp
  group GuiGenerated
    ../../../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../../../../generated/gui_generated/src/main_screen/: MainViewBase.cpp
    ../../../../generated/gui_generated/src/pooltemp_screen/: PoolTempViewBase.cpp
  group Generated
    ../../../../generated/images/src/: adjust_button.cpp adjust_button_pressed.cpp BitmapDatabase.cpp Main_Background.cpp ok_button.cpp ok_button_pressed.cpp peare_gul.cpp peare_hvid.cpp settings_background.cpp
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_verdana_10_4bpp.cpp Font_verdana_20_4bpp.cpp Font_verdana_45_4bpp.cpp FontGetters.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_45_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_45_4bpp.cpp
    ../../../../generated/images/src/__designer/: Blue_Slider_Horizontal_Medium_Indicators_Slider_Round_nob.cpp Blue_Slider_Horizontal_Medium_Slider_Round_back.cpp Blue_Slider_Horizontal_Medium_Slider_Round_fill.cpp Blue_Togglebars_Toggle_round_large_button_Off.cpp Blue_Togglebars_Toggle_round_large_button_On.cpp
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFXHAL
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
    ../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../../../../touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group gui
    ../../../../gui/src/common/: frontendapplication.cpp
    ../../../../gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../../../../gui/src/model/: model.cpp
    ../../../../gui/src/pooltemp_screen/: pooltemppresenter.cpp pooltempview.cpp
  group generated
    ../../../../generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp compressedfontcache.cpp compressedunmappedfontcache.cpp font_verdana_20_4bpp_0.cpp font_verdana_45_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_45_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_45_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../../../../generated/images/src/: bitmapdatabase.cpp image_adjust_button.cpp image_adjust_button_pressed.cpp image_main_background.cpp image_ok_button.cpp image_ok_button_pressed.cpp image_peare_gul.cpp image_peare_hvid.cpp image_settings_background.cpp svgdatabase.cpp
    ../../../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../../../generated/images/src/__designer/: image_blue_slider_horizontal_medium_indicators_slider_round_nob.cpp image_blue_slider_horizontal_medium_slider_round_back.cpp image_blue_slider_horizontal_medium_slider_round_fill.cpp image_blue_togglebars_toggle_round_large_button_off.cpp image_blue_togglebars_toggle_round_large_button_on.cpp
    ../../../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../../../generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../../../../generated/gui_generated/src/pooltemp_screen/: pooltempviewbase.cpp
